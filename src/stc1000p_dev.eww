<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stc1000p.ewp</path>
  </project>
  <batchBuild/>
</workspace>


